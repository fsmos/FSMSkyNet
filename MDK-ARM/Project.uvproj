# Keil uVision project Project.uvproj, settings and files
target FSMSwitch (ARM-ADS)
  device: Cortex-M1 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M1") ESEL
  output: FSMSwitch +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin --output=PO06fw.bin PO06_Output\PO06fw.axf
  AfterMake: copy.bat
  c flags: Optim=4 wLevel=2
  c include: ..\Libraries\CMSIS\inc;..\Libraries\CMSIS\CM1;..\Libraries\CMSIS\src;..\src;..\src\peripheral;..\src\driver;..\src\sip;..\src\ethernet;..\src\other;..\src\SDTP;..\src\snmp;..\src\Flash;..\src\abonent;..\src\sip_v2;..\src\experemental;..\src\PO_P168;..\src\radio;..\src\FSM;..\src\uart;..\src\rst_clk;..\src\RS485
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT6: RAM 0x50000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  group main
    ../src/: main.c HardFauld.c
  group periphery
    ../src/peripheral/: timer.c peripheral.c
  group ethernet
    ../src/ethernet/: EthernetMain.c
  group driver
    ../src/ethernet/: EthFunc.c
  group CMSIS
    ../Libraries/CMSIS/CM1/: system_MDR1986VE1T.c core_cm1.c
  group MDK-ARM
    ../Libraries/CMSIS/CM1/: startup_MDR1986VE1T.s
  group spl_by_AlexChas
    ../Libraries/CMSIS/src/: opora_port_defs.c
  group Flash
    ../src/Flash/: CRC32.c flashFunctions.c OPORA_eeprom.c
  group FSM
    ../src/FSM/: FSMClient.c
  group RS485
    ../src/RS485/: RS485.c RS485Switch.c
  group BLE
    ../src/BLE/: BLE.c BLESwitch.c
  group nRFC
    ../src/nRFC/: nRFC.c nRFCSwitch.c
